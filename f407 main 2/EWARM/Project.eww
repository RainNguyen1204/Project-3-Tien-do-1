<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\f407 main 2.ewp</path>
  </project>
  <batchBuild />
</workspace>
